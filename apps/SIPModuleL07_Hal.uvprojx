# Keil uVision project SIPModuleL07_Hal.uvprojx, settings and files
target SIPModule_G76S (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00030000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SIPModuleL07_Hal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_16CH SIPMODULE_BOARD HAYLEYS_MOTOR STM32L073xx USE_HAL_DRIVER HSE_VALUE=24000000 ANT_PA AT_COMMAND_FOR_SIP
  c include: .\include;..\boardl07;..\boardl07\CMSIS\Include;..\boardl07\interface\include;..\boardl07\STM32L0xx_HAL_Driver\Inc;..\boardl07\CMSIS\Device\ST\STM32L0xx\Include;.\LoRaMac;.\LoRaMac\crypto;..\common;..\common\crypto\include;..\FreeRTOS\Source\include;..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\peripherals\include;.\at_command
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group apps
    ./: main.c radio_task.c reporter_task.c timer_task.c uart_task.c
  group apps\LoRaMac
    ./LoRaMac/: LoRaMac.c
  group apps\LoRaMac\crypto
    ./LoRaMac/crypto/: LoRaMacCrypto.c
  group apps\at_command
    ./at_command/: at_command_list.c at_command_app.c
  group board
    ../boardl07/: stm32l0xx_it.c
  group board\interface
    ../boardl07/interface/: adc-board.c board.c eeprom-board.c gpio-board.c hwtimer-board.c rtc-board.c spi-board.c uart-board.c i2c-board.c
  group board\HalDriver
    ../boardl07/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group board\cmsis
    ../boardl07/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
    ../boardl07/CMSIS/Device/ST/STM32L0xx/Source/Templates/arm/: startup_stm32l073xx.s
  group common
    ../common/: crc16.c fifo.c utilities.c production.c
  group common\crypto
    ../common/crypto/: aes.c cmac.c
  group os
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os\portable
    ../FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group os\CMSIS_RTOS
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group peripherals
    ../peripherals/: sx1276.c
target SIPModule_G76S-lp (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: AT_L073_v_G76S +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_16CH SIPMODULE_BOARD STM32L073xx USE_HAL_DRIVER HSE_VALUE=24000000 ANT_PA AT_COMMAND_FOR_SIP LOW_POWER_MODE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SIPModule_G78S (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: SIPModuleL07_Hal +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_16CH SIPMODULE_BOARD STM32L073xx USE_HAL_DRIVER HSE_VALUE=24000000 ANT_PA AT_COMMAND_FOR_SIP SIPMODULE_G78S
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SIPModule_G78S-lp (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L073VZIx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: AT_L073_v_G78S +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_16CH SIPMODULE_BOARD STM32L073xx USE_HAL_DRIVER HSE_VALUE=24000000 ANT_PA AT_COMMAND_FOR_SIP SIPMODULE_G78S LOW_POWER_MODE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
