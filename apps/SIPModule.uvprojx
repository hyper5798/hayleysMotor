# Keil uVision project SIPModule.uvprojx, settings and files
target SIPModule (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SIPModule +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD USE_16CH USE_STDPERIPH_DRIVER SIPMODULE_BOARD
  c include: .\include;..\board\cmsis\device\include;..\board\interface\include;..\board\STM32L1xx_StdPeriph_Driver\inc;..\common;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\peripherals\include;.\at_command;.\LoRaMac;..\common\crypto\include;.\LoRaMac\crypto
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group app
    ./: main.c timer_task.c uart_task.c radio_task.c reporter_task.c
    ./at_command/: at_command_list.c at_command_app.c
    ./LoRaMac/: LoRaMac.c
    ./LoRaMac/crypto/: LoRaMacCrypto.c
  group board
    ../board/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_usart.c stm32l1xx_rtc.c stm32l1xx_rcc.c stm32l1xx_tim.c stm32l1xx_gpio.c stm32l1xx_exti.c stm32l1xx_syscfg.c stm32l1xx_i2c.c stm32l1xx_adc.c stm32l1xx_pwr.c stm32l1xx_spi.c stm32l1xx_flash.c stm32l1xx_dbgmcu.c
    ../board/interface/: gpio-board.c uart-board.c hwtimer-board.c i2c-board.c rtc-board.c spi-board.c eeprom-board.c board.c adc-board.c
    ../board/: stm32l1xx_it.c
    ../board/cmsis/device/: startup_stm32l1xx_md.s system_stm32l1xx.c
  group common
    ../common/: fifo.c utilities.c production.c crc16.c
    ../common/crypto/: aes.c cmac.c
  group os
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group peripherals
    ../peripherals/: sx1276.c
target SIPModule_LPM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: AT_L151_v +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD USE_16CH USE_STDPERIPH_DRIVER SIPMODULE_BOARD LOW_POWER_MODE
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
