# Keil uVision project SIPModule_Hal.uvprojx, settings and files
target SIPModule_Hal (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SIPModule_Hal
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_16CH SIPMODULE_BOARD STM32L151xBA USE_HAL_DRIVER LOW_POWER_MODE
  c include: .\include;..\board;..\board\CMSIS\Include;..\board\interface\include;..\board\STM32L1xx_HAL_Driver\Inc;..\board\CMSIS\Device\ST\STM32L1xx\Include;.\LoRaMac;.\LoRaMac\crypto;..\common;..\common\crypto\include;..\FreeRTOS\Source\include;..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\peripherals\include;.\at_command
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group apps
    ./: radio_task.c timer_task.c main.c reporter_task.c uart_task.c
  group board
    ../board/: stm32l1xx_it.c
  group common
    ../common/: crc16.c fifo.c utilities.c production.c
  group os
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group peripherals
    ../peripherals/: sx1276.c
  group apps\LoRaMac\crypto
    ./LoRaMac/crypto/: LoRaMacCrypto.c
  group apps\LoRaMac
    ./LoRaMac/: LoRaMac.c
  group board\interface
    ../board/interface/: adc-board.c board.c eeprom-board.c gpio-board.c hwtimer-board.c i2c-board.c rtc-board.c spi-board.c uart-board.c
  group board\HalDriver
    ../board/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_sdmmc.c
  group common\crypto
    ../common/crypto/: aes.c cmac.c
  group os\portable
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group os\CMSIS_RTOS
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group board\cmsis
    ../board/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../board/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xba.s
  group apps\at_command
    ./at_command/: at_command.c at_command_list.c
